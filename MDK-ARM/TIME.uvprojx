# Keil uVision project TIME.uvprojx, settings and files
target TIME (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: TIME
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\HARDWARE\TIMER;..\Drivers\sys;..\HARDWARE\STOP_WATCH;..\HARDWARE\OLED;..\HARDWARE\KEY;..\HARDWARE\REMOTE;..\HARDWARE\CLOCK;..\HARDWARE\CUTDOWN;..\HARDWARE\DS1302;..\HARDWARE\DS18B20;..\HARDWARE\NIXIE_TUBE;..\HARDWARE\DELAY_US;..\TEXT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio.c stm32f1xx_hal_cortex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/STOP_WATCH/: stop_watch.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/REMOTE/: remote.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/CLOCK/: clock.c
    ../HARDWARE/CUTDOWN/: cutdown.c
    ../HARDWARE/DS1302/: ds1302.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/NIXIE_TUBE/: Nixie_tube.c
    ../HARDWARE/DELAY_US/: delay.c
  group TEXT
    ../TEXT/: text.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
    ../Drivers/sys/: sys.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: stm32f1xx_hal_msp.c stm32f1xx_it.c main.c
software components: CMSIS:CORE 4.1.0
